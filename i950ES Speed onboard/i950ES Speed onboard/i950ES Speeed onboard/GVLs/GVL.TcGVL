{attribute 'qualified_only'}
VAR_GLOBAL
ControlSignals AT %QD0 : DWORD;
END_VAR
